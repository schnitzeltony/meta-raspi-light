# in meta-oe (!!) userland is added to dependency - we don't have it
DEPENDS_remove_rpi = "userland"
