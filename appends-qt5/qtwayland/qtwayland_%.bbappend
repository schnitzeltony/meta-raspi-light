# Raspi mesa does not have glx/dri
PACKAGECONFIG:remove:rpi = "xcomposite-glx"
