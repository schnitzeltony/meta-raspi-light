# Raspi mesa does not have glx/dri
PACKAGECONFIG_remove_rpi = "xcomposite-glx"
