COMPATIBLE_HOST_rpi  = ".*-linux*"
